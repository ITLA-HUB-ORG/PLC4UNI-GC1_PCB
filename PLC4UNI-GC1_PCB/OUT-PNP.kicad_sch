File: PLC4UNI-GC1_PCB/OUT-PNP.kicad_sch (KiCad schematic)
At the start: 5 parts, among them U9 BTS723GWXUMA1

Commit message: Actualizacion a la fecha
Connections:
- net +24V renamed VDC
